Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler, Heizen/Kühlen, Aufputz, 230 VAC, 3-stufiger Lüfterausgang 0…10 V oder dynamisch 0…10 V, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA601500, Raumtemperaturregler, Heizen/Kühlen, Aufputz, 230 VAC, 3-stufiger Lüfterausgang 0…10 V oder dynamisch 0…10 V
In: Raum
Description: Der Klimaregler KTRRB-117.169 wurde speziell zur Ansteuerung von EC-Gebläsekonvektoren, EC-Fancoilgeräten und anderen EC-lüfterunterstützten Klimaanlagen in 2- oder 4-Rohrleitungssystemen mit stromlos geschlossenen Ventilen entwickelt. Hierbei wird der KTRRB-117.169 als Einzelraum-Temperaturregler mit internem Fühler oder als externes Regelgerät mit optionalem Fernfühler verwendet. Der optionale externe Vorlauffühler dient der automatischen Umschaltung des Reglers in Heiz- oder Kühlmodus im 2-Rohr-Betrieb in Abhängigkeit der Vorlauftemperatur, alternativ ist dieser Eingang als H/K-Umschaltkontakt nutzbar. 3-stufiger Lüfterausgang 0–10 V mit Anpassung der einzelnen Lüfterstufen oder dynamisch 0–10 V zur Ansteuerung von EC-Lüftern. Ventilatorbetrieb in neutraler Zone AN/AUS wählbar. Bei Fühlerbruch oder Fühlerkurzschluss wird die Heizung mit einer Einschaltdauer von 30 % angesteuert um ein Auskühlen oder Frostschäden im Raum zu vermeiden. Mit einem internem Schalter kann der vorhanden Kontakteingang als ECO-Kontakt oder Standby-Kontakt konfiguriert werden. ECO-Funktion: Wird diese Funktion gewählt, wird im Heizbetrieb auf eine um 3 K geringere und im Kühlbetrieb auf eine um 3 K höhere Temperatur geregelt. Standby-Funktion: Wird diese Funktion gewählt, wird der Regler ausgeschaltet (Frostschutz weiterhin aktiv). Aufputz-/Wandmontage oder mittels Adapterplatte auf UP-Dose.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA601500; ModelLabel: KTRRB-117.169; GlobalTradeItemNumber: 4050528067173; ProductURL: https://alre.de/produkt_MA601500
Pset_Specification - NominalLength: 0.1107 m; NominalWidth: 0.11 m; NominalDepth: 0.026 m; NetWeight: 0.167
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: anthrazit; Breite: 110; Höhe: 110.7; Tiefe: 26; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 230 V AC; Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 5; Differenzwert: 1; Sensor extern: no; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA601500.pdf
